# GHz S RI R 50
!freq	ReS11	ImS11	ReS21	ImS21	ReS12	ImS12	ReS22	ImS22
! Worked out from all points (two-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   highest |S21| = -2.13 dB at 723.1 GHz (marker M1); lowest = -25.2 dB at 503.1 GHz (marker M2)
!   |S21| within 3 dB of the highest: 720 GHz to 734.1 GHz (14.03 GHz wide, 1.93 % of centre)
!   lowest |S11| = -46.4 dB at 503.1 GHz (marker M3), VSWR 1.01, Z = 49.9 + j0.453 ohm
!   |S11| at or under -10 dB: 509.2 GHz to 522.8 GHz (13.62 GHz wide, 2.64 % of centre); 525.2 GHz to 547.4 GHz (22.21 GHz wide, 4.14 % of centre); 548.1 GHz to 563 GHz (14.84 GHz wide, 2.67 % of centre) (the widest 3 of 61)
!   |S22| runs from -38.4 to -7.1 dB; largest |S21 - S12| = 0
!   the Smith chart shows 500 GHz to 517.5 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 0.98, -0.03; 507.5 GHz: 1.39, -0.05; 509.4 GHz: 0.61, +0.09; 515 GHz: 1.33, -0.40; 517.5 GHz: 1.02, -0.24
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 500 GHz  -34.3  -20.2  -20.2  -13.4
! 503.1 GHz  -46.4  -25.2  -25.2  -10.5
! 507.5 GHz  -15.6  -9.3  -9.3  -17.0
! 509.4 GHz  -12.2  -9.8  -9.8  -17.5
! 512.5 GHz  -43.2  -24.8  -24.8  -18.5
! 515 GHz  -13.2  -10.8  -10.8  -18.2
! 517.5 GHz  -18.4  -14.3  -14.3  -17.5
! 519.4 GHz  -27.3  -19.6  -19.6  -16.4
! 523.8 GHz  -15.2  -10.2  -10.2  -13.4
! 536.2 GHz  -28.0  -18.1  -18.1  -8.2
! 541.9 GHz  -14.4  -11.7  -11.7  -7.3
! 570 GHz  -12.7  -11.6  -11.6  -20.5
! 583.8 GHz  -9.3  -11.1  -11.1  -9.8
! 625 GHz  -11.1  -8.7  -8.7  -25.7
! 644.4 GHz  -8.8  -7.3  -7.3  -11.8
! 666.9 GHz  -12.5  -8.8  -8.8  -14.4
! 680.6 GHz  -10.1  -6.7  -6.7  -20.7
! 686.2 GHz  -5.0  -6.0  -6.0  -38.4
! 694.4 GHz  -7.4  -6.5  -6.5  -17.3
! 708.8 GHz  -16.0  -8.3  -8.3  -14.3
! 723.1 GHz  -5.1  -2.1  -2.1  -15.2
! 750 GHz  -13.4  -11.2  -11.2  -20.6
