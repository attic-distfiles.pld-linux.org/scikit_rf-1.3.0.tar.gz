!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -12.1 dB at 500.6 GHz (marker M1), VSWR 1.66, Z = 44.9 + j23.8 ohm
!   |S11| at or under -10 dB: start of sweep to 500.9063 GHz; 503.7321 GHz to 503.822 GHz (89.88 MHz wide, 0.0178 % of centre)
!   the Smith chart shows 500 GHz to 505.6 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 0.91, -0.51; 501.9 GHz: 0.32, +0.08; 502.5 GHz: 1.79, +1.17; 503.8 GHz: 0.71, +0.47; 505 GHz: 0.39, +0.28; 505.6 GHz: 1.83, +0.64
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! magnitudes (dB):
! f  S11
! 500 GHz  -11.5
! 500.6 GHz  -12.1
! 501.9 GHz  -5.6
! 502.5 GHz  -6.6
! 503.8 GHz  -10.1
! 505 GHz  -6.4
! 505.6 GHz  -8.8
! 508.8 GHz  -4.0
! 512.5 GHz  -8.6
! 516.9 GHz  -3.0
! 521.2 GHz  -7.1
! 523.8 GHz  -0.8
! 526.2 GHz  -5.0
! 528.1 GHz  -6.7
! 531.2 GHz  -2.3
! 535.6 GHz  -6.0
! 541.2 GHz  -5.1
! 545 GHz  -5.0
! 549.4 GHz  -5.8
! 552.5 GHz  -4.6
! 562.5 GHz  -7.2
! 593.8 GHz  -6.5
! 625 GHz  -6.4
! 656.2 GHz  -4.9
! 687.5 GHz  -4.5
! 718.8 GHz  -2.7
! 739.4 GHz  -2.1
! 750 GHz  -4.3
