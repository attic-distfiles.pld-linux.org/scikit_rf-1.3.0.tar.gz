!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -37.4 dB at 505 GHz (marker M1), VSWR 1.03, Z = 48.7 - j0.0743 ohm
!   |S11| at or under -10 dB: start of sweep to 518 GHz; 518.3 GHz to 523.5 GHz (5.136 GHz wide, 0.986 % of centre); 523.8 GHz to end of sweep
!   the Smith chart shows 500 GHz to 517.5 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 1.05, +0.01; 504.4 GHz: 0.74, +0.06; 511.2 GHz: 1.42, +0.18; 517.5 GHz: 1.05, -0.17
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! magnitudes (dB):
! f  S11
! 500 GHz  -31.8
! 501.2 GHz  -20.9
! 504.4 GHz  -16.1
! 505 GHz  -37.4
! 506.2 GHz  -14.3
! 508.8 GHz  -15.8
! 511.2 GHz  -14.5
! 517.5 GHz  -21.5
! 521.2 GHz  -15.4
! 524.4 GHz  -22.0
! 527.5 GHz  -19.6
! 531.2 GHz  -10.5
! 562.5 GHz  -18.2
! 593.8 GHz  -14.7
! 625 GHz  -15.1
! 656.2 GHz  -23.6
! 687.5 GHz  -17.1
! 690.6 GHz  -16.4
! 696.9 GHz  -16.1
! 700 GHz  -19.5
! 701.9 GHz  -13.9
! 709.4 GHz  -21.7
! 716.9 GHz  -14.4
! 718.8 GHz  -21.4
! 739.4 GHz  -16.4
! 742.5 GHz  -12.7
! 746.9 GHz  -19.1
! 750 GHz  -27.4
