!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -12.3 dB at 500 GHz (marker M1), VSWR 1.64, Z = 82.1 - j2.41 ohm
!   |S11| at or under -10 dB: start of sweep to 500.5652 GHz; 504.2049 GHz to 504.5989 GHz (394 MHz wide, 0.0781 % of centre); 511.8066 GHz to 511.9958 GHz (189.2 MHz wide, 0.037 % of centre) (the widest 3 of 4)
!   the Smith chart shows 500 GHz to 505.6 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 1.64, -0.05; 501.9 GHz: 0.49, -0.86; 502.5 GHz: 0.41, +0.15; 503.8 GHz: 0.42, -0.18; 505 GHz: 0.53, -0.38; 505.6 GHz: 0.38, +0.45
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! magnitudes (dB):
! f  S11
! 500 GHz  -12.3
! 501.9 GHz  -4.7
! 502.5 GHz  -7.4
! 503.8 GHz  -7.4
! 505 GHz  -8.3
! 505.6 GHz  -5.6
! 508.1 GHz  -5.0
! 512.5 GHz  -8.8
! 516.9 GHz  -5.6
! 521.2 GHz  -5.7
! 524.4 GHz  -0.4
! 526.9 GHz  -7.3
! 531.2 GHz  -2.5
! 535.6 GHz  -6.2
! 540 GHz  -3.3
! 543.8 GHz  -5.0
! 550 GHz  -5.9
! 562.5 GHz  -5.9
! 593.8 GHz  -6.0
! 625 GHz  -5.7
! 656.2 GHz  -5.9
! 687.5 GHz  -4.5
! 718.8 GHz  -4.3
! 731.9 GHz  -3.7
! 735 GHz  -2.2
! 745 GHz  -1.6
! 748.1 GHz  -7.0
! 750 GHz  -3.7
