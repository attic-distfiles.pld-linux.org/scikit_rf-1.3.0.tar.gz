!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -55.1 dB at 635 GHz (marker M1), VSWR 1.00, Z = 50.2 + j0.092 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   the Smith chart shows 592.5 GHz to 676.9 GHz only
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! magnitudes (dB):
! f  S11
! 500 GHz  -24.7
! 518.1 GHz  -15.5
! 521.2 GHz  -26.9
! 525 GHz  -19.5
! 528.1 GHz  -29.0
! 531.2 GHz  -18.1
! 562.5 GHz  -28.4
! 571.2 GHz  -21.4
! 574.4 GHz  -33.7
! 579.4 GHz  -22.4
! 582.5 GHz  -30.8
! 586.9 GHz  -22.6
! 590 GHz  -30.2
! 593.8 GHz  -23.3
! 601.9 GHz  -23.3
! 606.2 GHz  -38.4
! 613.1 GHz  -20.1
! 625 GHz  -23.7
! 635 GHz  -55.1
! 649.4 GHz  -21.5
! 653.1 GHz  -30.8
! 656.2 GHz  -24.7
! 687.5 GHz  -35.1
! 718.8 GHz  -21.0
! 738.1 GHz  -25.8
! 743.8 GHz  -17.0
! 747.5 GHz  -39.6
! 750 GHz  -21.2
