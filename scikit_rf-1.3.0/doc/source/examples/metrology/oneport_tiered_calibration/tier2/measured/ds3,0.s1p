!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -27.5 dB at 505 GHz (marker M1), VSWR 1.09, Z = 54.3 + j0.891 ohm
!   |S11| at or under -10 dB: 558.1 GHz to 616.8 GHz (58.64 GHz wide, 9.98 % of centre); 616.9 GHz to 625.6 GHz (8.672 GHz wide, 1.4 % of centre); 625.7 GHz to 668.6 GHz (42.99 GHz wide, 6.64 % of centre) (the widest 3 of 40)
!   the Smith chart shows 500 GHz to 510 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 0.88, -0.19; 503.1 GHz: 0.76, -0.45; 505 GHz: 1.09, +0.02; 507.5 GHz: 1.37, -0.42; 510 GHz: 0.74, -0.13
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! magnitudes (dB):
! f  S11
! 500 GHz  -18.4
! 503.1 GHz  -11.1
! 505 GHz  -27.5
! 506.9 GHz  -8.0
! 507.5 GHz  -12.6
! 508.1 GHz  -10.0
! 510 GHz  -15.4
! 512.5 GHz  -25.7
! 515.6 GHz  -10.5
! 518.1 GHz  -8.3
! 521.2 GHz  -12.7
! 523.8 GHz  -5.3
! 526.9 GHz  -12.5
! 531.2 GHz  -9.8
! 535 GHz  -11.7
! 540.6 GHz  -10.7
! 543.8 GHz  -14.5
! 548.8 GHz  -10.2
! 551.9 GHz  -16.9
! 562.5 GHz  -14.9
! 593.8 GHz  -11.3
! 625 GHz  -13.5
! 656.2 GHz  -14.2
! 687.5 GHz  -10.9
! 718.8 GHz  -13.2
! 720 GHz  -12.2
! 741.9 GHz  -12.8
! 750 GHz  -13.2
