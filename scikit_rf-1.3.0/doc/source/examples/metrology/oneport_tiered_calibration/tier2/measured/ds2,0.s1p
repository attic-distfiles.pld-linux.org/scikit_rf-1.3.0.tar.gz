!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -22.2 dB at 526.2 GHz (marker M1), VSWR 1.17, Z = 45 - j5.47 ohm
!   |S11| at or under -10 dB: 550.3 GHz to 636.2 GHz (85.91 GHz wide, 14.5 % of centre); 640.6 GHz to 669.3 GHz (28.65 GHz wide, 4.37 % of centre); 669.4 GHz to 683.5 GHz (14.12 GHz wide, 2.09 % of centre) (the widest 3 of 37)
!   the Smith chart shows 523.8 GHz to 531.2 GHz only
!   S11 on the Smith chart (normalised r, x): 523.8 GHz: 0.45, +0.01; 525 GHz: 0.80, -0.07; 528.1 GHz: 1.26, -0.44; 530 GHz: 1.11, +0.19; 531.2 GHz: 1.56, -0.15
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! magnitudes (dB):
! f  S11
! 500 GHz  -16.3
! 508.1 GHz  -8.9
! 511.2 GHz  -19.1
! 516.9 GHz  -7.9
! 521.2 GHz  -13.2
! 523.8 GHz  -8.5
! 524.4 GHz  -3.4
! 525 GHz  -18.7
! 526.2 GHz  -22.2
! 528.1 GHz  -13.2
! 530 GHz  -19.6
! 531.2 GHz  -12.9
! 535.6 GHz  -11.6
! 550 GHz  -7.7
! 556.2 GHz  -15.5
! 562.5 GHz  -14.3
! 593.8 GHz  -14.4
! 596.2 GHz  -13.4
! 625 GHz  -15.1
! 656.2 GHz  -14.6
! 687.5 GHz  -12.7
! 718.8 GHz  -8.8
! 728.8 GHz  -9.4
! 731.2 GHz  -10.3
! 734.4 GHz  -11.1
! 741.2 GHz  -9.3
! 744.4 GHz  -13.7
! 750 GHz  -13.1
