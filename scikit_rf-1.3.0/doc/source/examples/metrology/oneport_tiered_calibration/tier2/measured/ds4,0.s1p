!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -25.7 dB at 748.8 GHz (marker M1), VSWR 1.11, Z = 45.3 - j1.54 ohm
!   |S11| at or under -10 dB: 556.3 GHz to 600.6 GHz (44.33 GHz wide, 7.66 % of centre); 600.7 GHz to 692.8 GHz (92.1 GHz wide, 14.2 % of centre); 707.5 GHz to 732.1 GHz (24.57 GHz wide, 3.41 % of centre) (the widest 3 of 25)
!   the Smith chart shows 740 GHz to 750 GHz only
!   S11 on the Smith chart (normalised r, x): 740 GHz: 0.75, -0.47; 741.9 GHz: 0.55, +0.16; 744.4 GHz: 1.44, +0.61; 745.6 GHz: 1.34, +0.19; 747.5 GHz: 0.79, -0.20; 750 GHz: 0.70, +0.24
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! magnitudes (dB):
! f  S11
! 500 GHz  -25.1
! 501.9 GHz  -11.4
! 505 GHz  -18.2
! 508.1 GHz  -13.2
! 512.5 GHz  -19.2
! 517.5 GHz  -9.4
! 521.2 GHz  -13.0
! 523.8 GHz  -4.1
! 526.9 GHz  -13.0
! 531.2 GHz  -7.0
! 536.9 GHz  -10.7
! 540 GHz  -8.8
! 545 GHz  -16.0
! 548.1 GHz  -8.5
! 562.5 GHz  -13.8
! 593.8 GHz  -11.2
! 625 GHz  -12.0
! 656.2 GHz  -11.9
! 687.5 GHz  -11.2
! 718.8 GHz  -16.0
! 735.6 GHz  -12.3
! 740 GHz  -10.6
! 741.9 GHz  -10.2
! 744.4 GHz  -10.5
! 745.6 GHz  -15.7
! 747.5 GHz  -15.8
! 748.8 GHz  -25.7
! 750 GHz  -13.1
