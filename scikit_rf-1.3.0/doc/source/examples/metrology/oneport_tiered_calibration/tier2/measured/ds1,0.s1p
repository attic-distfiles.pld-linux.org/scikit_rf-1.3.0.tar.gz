!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -21.9 dB at 522.5 GHz (marker M1), VSWR 1.17, Z = 53.6 - j7.55 ohm
!   |S11| at or under -10 dB: 550.7 GHz to 563.7 GHz (13.03 GHz wide, 2.34 % of centre); 563.8 GHz to 684.4 GHz (120.6 GHz wide, 19.3 % of centre); 684.4 GHz to 694.3 GHz (9.861 GHz wide, 1.43 % of centre) (the widest 3 of 35)
!   the Smith chart shows 518.8 GHz to 525 GHz only
!   S11 on the Smith chart (normalised r, x): 518.8 GHz: 0.97, +0.35; 520.6 GHz: 0.60, +0.02; 523.8 GHz: 0.78, -0.41; 524.4 GHz: 0.32, +1.02; 525 GHz: 1.13, -0.31
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! magnitudes (dB):
! f  S11
! 500 GHz  -16.4
! 508.8 GHz  -11.2
! 511.9 GHz  -13.1
! 516.9 GHz  -7.3
! 518.8 GHz  -15.1
! 520.6 GHz  -12.2
! 522.5 GHz  -21.9
! 523.8 GHz  -11.9
! 524.4 GHz  -2.7
! 525 GHz  -16.1
! 527.5 GHz  -15.1
! 531.2 GHz  -10.2
! 535.6 GHz  -13.3
! 541.2 GHz  -12.8
! 544.4 GHz  -19.0
! 549.4 GHz  -13.2
! 552.5 GHz  -19.0
! 562.5 GHz  -13.2
! 593.8 GHz  -15.8
! 625 GHz  -12.9
! 656.2 GHz  -11.9
! 687.5 GHz  -13.5
! 718.8 GHz  -8.7
! 740.6 GHz  -13.2
! 741.9 GHz  -10.2
! 745 GHz  -12.5
! 747.5 GHz  -15.5
! 750 GHz  -12.4
