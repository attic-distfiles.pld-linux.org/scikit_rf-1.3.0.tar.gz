!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11
! Worked out from all points (one-port):
!   401 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -31.5 dB at 500 GHz (marker M1), VSWR 1.05, Z = 52.1 + j1.72 ohm
!   |S11| at or under -10 dB: start of sweep to 508.7 GHz; 550.8 GHz to 716.2 GHz (165.4 GHz wide, 26.1 % of centre); 724.4 GHz to 743.7 GHz (19.34 GHz wide, 2.63 % of centre) (the widest 3 of 19)
!   the Smith chart shows 500 GHz to 510.6 GHz only
!   S11 on the Smith chart (normalised r, x): 500 GHz: 1.04, +0.03; 503.1 GHz: 0.72, -0.06; 505.6 GHz: 1.08, +0.33; 510.6 GHz: 1.00, -0.27
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! magnitudes (dB):
! f  S11
! 500 GHz  -31.5
! 501.9 GHz  -13.0
! 503.1 GHz  -15.6
! 505.6 GHz  -15.9
! 510 GHz  -6.8
! 510.6 GHz  -17.4
! 517.5 GHz  -9.0
! 520.6 GHz  -12.9
! 523.8 GHz  -5.5
! 528.1 GHz  -15.6
! 531.2 GHz  -6.4
! 536.2 GHz  -12.7
! 540 GHz  -11.9
! 545 GHz  -17.8
! 548.1 GHz  -10.6
! 562.5 GHz  -13.2
! 593.8 GHz  -13.1
! 625 GHz  -12.1
! 656.2 GHz  -11.8
! 687.5 GHz  -13.2
! 699.4 GHz  -13.3
! 715.6 GHz  -11.6
! 718.8 GHz  -10.7
! 735 GHz  -11.7
! 743.8 GHz  -9.7
! 745 GHz  -15.6
! 747.5 GHz  -17.3
! 750 GHz  -13.5
