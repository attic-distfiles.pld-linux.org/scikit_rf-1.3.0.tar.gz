!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   721 points, 60 GHz to 90 GHz, reference 50 ohm
!   highest |S21| = -89.91 dB at 82.46 GHz (marker M1); lowest = -127.5 dB at 89.33 GHz (marker M2)
!   lowest |S11| = -66.4 dB at 70.21 GHz (marker M3), VSWR 1.00, Z = 50 + j0.00955 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -26.7 to 2.9 dB; largest |S21 - S12| = 1.4
!   the Smith chart shows 70.08 GHz to 70.33 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 60 GHz  -29.2  -101.3  -2.7  -1.5
! 65 GHz  -39.8  -101.1  -1.3  -1.3
! 66.71 GHz  -28.3  -95.3  -2.2  -0.1
! 67.54 GHz  -44.3  -104.4  0.9  -5.3
! 69.33 GHz  -30.5  -96.5  0.0  -2.8
! 70 GHz  -37.1  -101.9  -0.6  0.3
! 70.21 GHz  -66.4  -114.4  -1.0  -1.5
! 70.88 GHz  -29.0  -97.2  0.6  -8.8
! 71.96 GHz  -53.2  -101.2  -12.8  1.5
! 72.67 GHz  -28.4  -94.5  -12.7  -1.1
! 73.42 GHz  -46.6  -95.3  1.6  -1.3
! 75 GHz  -34.7  -100.5  0.7  -7.6
! 75.79 GHz  -43.3  -101.0  -9.3  -2.9
! 76.92 GHz  -31.4  -107.4  -1.6  -4.1
! 77.75 GHz  -50.1  -111.5  -1.1  -0.8
! 78.38 GHz  -30.3  -106.4  -7.6  -1.1
! 80 GHz  -34.0  -92.5  -3.3  0.2
! 82.46 GHz  -43.3  -89.9  -4.3  -1.3
! 85 GHz  -34.6  -105.7  -2.4  -5.3
! 86.46 GHz  -32.7  -103.7  -9.7  -5.0
! 89.33 GHz  -36.3  -127.5  -0.8  0.4
! 90 GHz  -35.4  -97.8  -3.2  0.8
