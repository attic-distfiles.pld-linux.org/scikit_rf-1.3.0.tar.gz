!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   721 points, 60 GHz to 90 GHz, reference 50 ohm
!   highest |S21| = -88.58 dB at 64.33 GHz (marker M1); lowest = -127.6 dB at 75.83 GHz (marker M2)
!   lowest |S11| = 1.8 dB at 78.92 GHz (marker M3)
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -30.5 to 2.9 dB; largest |S21 - S12| = 1.4
!   the Smith chart shows 78.83 GHz to 79.04 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 60 GHz  5.0  -104.8  -1.7  0.4
! 60.5 GHz  4.4  -98.7  -2.0  0.6
! 61.5 GHz  3.5  -94.7  -3.3  2.0
! 62.08 GHz  4.0  -109.8  -10.9  -18.7
! 62.71 GHz  4.0  -102.5  -1.4  1.7
! 62.96 GHz  5.4  -100.0  -0.3  -1.3
! 64.33 GHz  4.3  -88.6  -2.6  -6.2
! 65 GHz  2.9  -107.7  0.3  0.3
! 70 GHz  4.5  -97.6  -0.2  -2.6
! 75 GHz  4.1  -99.4  0.3  -3.4
! 75.83 GHz  4.1  -127.6  -9.3  -3.6
! 78.08 GHz  3.9  -105.4  0.0  -0.1
! 78.62 GHz  3.8  -100.6  -0.2  -30.5
! 78.92 GHz  1.8  -98.4  -3.8  -0.7
! 80 GHz  3.1  -101.6  -1.5  -7.5
! 85 GHz  3.5  -103.7  -3.0  -1.5
! 86 GHz  3.9  -106.8  -3.7  -1.9
! 86.29 GHz  4.1  -108.6  -5.1  0.1
! 86.58 GHz  3.7  -95.0  1.9  -1.3
! 87.54 GHz  5.6  -102.6  -7.1  -7.8
! 89.08 GHz  5.1  -96.3  -2.8  2.7
! 90 GHz  4.2  -96.9  -4.1  -11.2
