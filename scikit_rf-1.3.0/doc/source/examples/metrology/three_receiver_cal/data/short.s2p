!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   721 points, 60 GHz to 90 GHz, reference 50 ohm
!   highest |S21| = -89.15 dB at 82.71 GHz (marker M1); lowest = -129.3 dB at 63.88 GHz (marker M2)
!   lowest |S11| = 2.0 dB at 68.08 GHz (marker M3)
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -30.1 to 3.0 dB; largest |S21 - S12| = 1.4
!   the Smith chart shows 68 GHz to 68.17 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 60 GHz  4.6  -96.1  -0.1  1.7
! 60.5 GHz  3.5  -106.5  -12.9  -7.8
! 60.79 GHz  5.2  -101.5  0.6  -6.7
! 63.88 GHz  5.0  -129.3  2.2  -2.0
! 65 GHz  3.0  -97.0  2.0  -6.4
! 65.83 GHz  4.7  -104.6  -2.7  -7.0
! 66.62 GHz  4.4  -104.3  -0.7  1.5
! 68.08 GHz  2.0  -101.1  -4.2  -7.4
! 69.25 GHz  5.5  -93.0  -2.8  0.7
! 70 GHz  4.4  -98.3  -1.9  1.8
! 75 GHz  3.1  -114.2  -5.3  -3.2
! 75.38 GHz  4.8  -106.5  -0.3  1.7
! 76.29 GHz  4.6  -95.9  -0.4  -7.6
! 76.83 GHz  5.1  -110.6  -0.3  1.0
! 80 GHz  3.2  -104.7  -0.5  -0.3
! 82.71 GHz  6.7  -89.1  0.5  -6.7
! 85 GHz  4.7  -99.3  -3.2  -3.8
! 85.92 GHz  4.4  -95.9  -0.6  -4.9
! 86.17 GHz  4.8  -111.8  -0.8  -4.9
! 86.62 GHz  5.0  -99.5  -0.3  -0.4
! 87.46 GHz  5.4  -94.9  1.1  -1.0
! 90 GHz  3.5  -94.4  -0.8  2.7
